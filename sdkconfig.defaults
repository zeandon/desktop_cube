## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="DianGroup"
CONFIG_EXAMPLE_WIFI_PASSWORD="DianGroup2002"
```
